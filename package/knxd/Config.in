## package/knxd/Config.in
```kconfig
config BR2_PACKAGE_HOMEEREG
        bool "knxd"
        help
          knxd 

          https://github.com/knxd/knxd
```
